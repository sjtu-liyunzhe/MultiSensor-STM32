# Keil uVision project 4ch_Ultrasound.uvprojx, settings and files
target 4ch_Ultrasound (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767VITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: 4ch_Ultrasound +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ..\CORE;..\HALLIB\Inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE;..\HARDWARE\BF;..\HARDWARE\PULSER;..\HARDWARE\DAC;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\OSC;..\HARDWARE\FIFO;..\HARDWARE\ADC;..\HARDWARE\ETHERNET;..\M8266WIFI;..\HARDWARE\EXTI;..\HARDWARE\MATRIX;..\HARDWARE\FEATURE;..\HARDWARE\LDA;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\HARDWARE\ADS1299;..\HARDWARE\EMGProcessing;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\IMUCollecting;..\FreeRTOS\include;..\HARDWARE\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c system_stm32f7xx.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BF/: bf.c
    ../HARDWARE/PULSER/: pulser.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ETHERNET/: ethernet.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/MATRIX/: matrix.c
    ../HARDWARE/ADS1299/: ads1299.c
    ../HARDWARE/EMGProcessing/: EMGProcessing.c
    ../HARDWARE/IMUCollecting/: IMUCollecting.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu_0.c inv_mpu_1.c inv_mpu_2.c inv_mpu_3.c inv_mpu_dmp_motion_driver_0.c inv_mpu_dmp_motion_driver_1.c inv_mpu_dmp_motion_driver_2.c inv_mpu_dmp_motion_driver_3.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/CQUEUE/: cQueue.c
  group M8266WIFI
    ../M8266WIFI/: M8266WIFIDrv_STM32F7xx.lib M8266HostIf_STM32xx.c M8266WIFI_ops.c test_m8266wifi.c wifi.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
